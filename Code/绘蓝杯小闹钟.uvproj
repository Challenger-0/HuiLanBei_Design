# Keil uVision project 绘蓝杯小闹钟.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 绘蓝杯小闹钟 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c dataTypeDef.h graphics.c graphics.h I2C.c I2C.h SSD1306.c SSD1306.h STC15W.h GUI.c GUI.h WS2812.c WS2812.h Timer.c Timer.h UART.c UART.h PCF8563T.c PCF8563T.h note.c note.h I2C_low_speed.c I2C_low_speed.h BCD.c BCD.h AHT20.c AHT20.h EEPROM.c EEPROM.h MP3Player.c MP3Player.h config.h E2PROM .h E2PROM.c
